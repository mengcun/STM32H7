# Keil uVision project STM32H7_CoreBoard.uvprojx, settings and files
target STM32H7_CoreBoard (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32H743IITx STMicroelectronics
  pack: Keil.STM32H7xx_DFP.2.1.0
  cpu: IRAM(0x20000000,0x00020000) IRAM2(0x24000000,0x00080000) IROM(0x08000000,0x00200000) CPUTYPE("Cortex-M7") FPU3(DFPU) CLOCK(12000000) ELITTLE
  output: STM32H7_CoreBoard_Exe +hex
  c flags: Optim=4 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,STM32H743xx,USE_STM32H743II_COREBOARD
  c misc: --C99
  c include: ..\AppUser\Core;..\AppUser\Utilities\CPU;..\AppUser\Utilities\Fonts;..\Drivers\CMSIS\Include;..\Drivers\CMSIS\Device\ST\STM32H7xx\Include;..\Drivers\STM32H7xx_HAL_Driver\Inc;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\LED;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\USART1;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\RGB_LCD;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\SDRAM;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\MPU;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\Soft_Timer;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\Hard_Timer;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\WDG;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\RTC;..\Drivers\BSP\STM32H743II_CoreBoard_Bsp\PWM
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x200000
  memory RVCT9: RAM 0x20000000 size 0x20000
  memory RVCT10: RAM 0x24000000 size 0x80000
  group Documents
    ../Documentation/: BugListInfo.txt REF.txt
  group AppUser/Core
    ../AppUser/Core/: main.c stm32h7xx_it.c includes.h stm32h7xx_hal_conf.h
  group AppUser/Utilities
    ../AppUser/Utilities/Fonts/: font.h
    ../AppUser/Utilities/ULibs/: user_lib.c
  group Drivers/BSP/STM32H7_CoreBoard
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/: stm32h743ii_coreboard_bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/LED/: Led_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/MPU/: Mpu_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/RGB_LCD/: Lcd_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/SDRAM/: SDRAM_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/Soft_Timer/: Software_Timer_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/USART1/: Usart1_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/Hard_Timer/: Hardware_Timer_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/WDG/: Wdg_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/RTC/: Rtc_Bsp.c
    ../Drivers/BSP/STM32H743II_CoreBoard_Bsp/PWM/: Pwm_Bsp.c
  group Drivers/CMSIS
    ../Drivers/CMSIS/Device/ST/STM32H7xx/Source/Templates/: system_stm32h7xx.c
  group Drivers/STM32Hxx_HAL_Driver
    ../Drivers/STM32H7xx_HAL_Driver/Src/: stm32h7xx_hal.c stm32h7xx_hal_adc.c stm32h7xx_hal_adc_ex.c stm32h7xx_hal_cec.c stm32h7xx_hal_comp.c stm32h7xx_hal_cortex.c stm32h7xx_hal_crc.c stm32h7xx_hal_crc_ex.c stm32h7xx_hal_cryp.c stm32h7xx_hal_cryp_ex.c stm32h7xx_hal_dac.c stm32h7xx_hal_dac_ex.c stm32h7xx_hal_dcmi.c stm32h7xx_hal_dfsdm.c stm32h7xx_hal_dma.c stm32h7xx_hal_dma_ex.c stm32h7xx_hal_dma2d.c stm32h7xx_hal_eth.c stm32h7xx_hal_eth_ex.c stm32h7xx_hal_fdcan.c stm32h7xx_hal_flash.c stm32h7xx_hal_flash_ex.c stm32h7xx_hal_gpio.c stm32h7xx_hal_hash.c stm32h7xx_hal_hash_ex.c stm32h7xx_hal_hcd.c stm32h7xx_hal_hrtim.c stm32h7xx_hal_hsem.c stm32h7xx_hal_i2c.c stm32h7xx_hal_i2c_ex.c stm32h7xx_hal_i2s.c stm32h7xx_hal_i2s_ex.c stm32h7xx_hal_irda.c stm32h7xx_hal_iwdg.c stm32h7xx_hal_jpeg.c stm32h7xx_hal_lptim.c stm32h7xx_hal_ltdc.c stm32h7xx_hal_mdios.c stm32h7xx_hal_mdma.c stm32h7xx_hal_mmc.c stm32h7xx_hal_mmc_ex.c stm32h7xx_hal_nand.c stm32h7xx_hal_nor.c stm32h7xx_hal_opamp.c stm32h7xx_hal_opamp_ex.c stm32h7xx_hal_pcd.c stm32h7xx_hal_pcd_ex.c stm32h7xx_hal_pwr.c stm32h7xx_hal_pwr_ex.c stm32h7xx_hal_qspi.c stm32h7xx_hal_rcc.c stm32h7xx_hal_rcc_ex.c stm32h7xx_hal_rng.c stm32h7xx_hal_rtc.c stm32h7xx_hal_rtc_ex.c stm32h7xx_hal_sai.c stm32h7xx_hal_sai_ex.c stm32h7xx_hal_sd.c stm32h7xx_hal_sd_ex.c stm32h7xx_hal_sdram.c stm32h7xx_hal_smartcard.c stm32h7xx_hal_smartcard_ex.c stm32h7xx_hal_smbus.c stm32h7xx_hal_spdifrx.c stm32h7xx_hal_spi.c stm32h7xx_hal_spi_ex.c stm32h7xx_hal_sram.c stm32h7xx_hal_swpmi.c stm32h7xx_hal_tim.c stm32h7xx_hal_tim_ex.c stm32h7xx_hal_uart.c stm32h7xx_hal_uart_ex.c stm32h7xx_hal_usart.c stm32h7xx_hal_wwdg.c stm32h7xx_ll_delayblock.c stm32h7xx_ll_fmc.c stm32h7xx_ll_sdmmc.c stm32h7xx_ll_usb.c
  group Projectsr/MDK-ARM
    ./: startup_stm32h743xx.s
  group Template_C_H
    ../Template_C_H/: Template.c Template.h
